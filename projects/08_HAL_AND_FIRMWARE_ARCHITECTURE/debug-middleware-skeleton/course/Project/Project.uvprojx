# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HXTAL_VALUE=8000000
  c include: ..\Middleware;..\Hardware;..\User;..\Middleware\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Middleware
    ../Middleware/usart/: Usart0.c
software components: CMSIS:CORE 5.6.0, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:USART 3.0.2
